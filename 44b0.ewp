# IAR project 44b0.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: S3C44B0x Samsung S3C44B0x
  ICCARM.CCIncludePath2: inc\44b0lib; inc\ledlib; inc\configure; inc\lcd; inc\led; inc\AD; inc\DMA; inc\RTC
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: inc\startup
  OBJCOPY.OOCOutputFile: 44b0.srec
  ILINK.IlinkOutputFile: 44b0.out
  ILINK.IlinkIcfFile: E:\44b0\44b0.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group 44b0lib
    lib/44b0lib/: 44blib.c
    lib/ledlib/: ledlib.c
  group AD
    srcs/AD/: ad.c
  group configure
    inc/configure/: configure.h
  group DMA
    srcs/DMA/: dma.c
  group key
    srcs/key/: key.c
  group LCD
    srcs/LCD/: dispchar.c dispgraph.c lcdlib.c
  group leddemo
    srcs/leddemo/: leddemo.c
  group paomadeng
    srcs/paomadeng/: led.c
  group startup
    srcs/startup/: 44binit.s79
  group watchdog
    srcs/watchdog/: watchdog.c
